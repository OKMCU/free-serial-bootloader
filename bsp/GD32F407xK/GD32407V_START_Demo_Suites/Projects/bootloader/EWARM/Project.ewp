# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F407xK GD GD32F407xK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F407
  ICCARM.CCIncludePath2: ..; ..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include; ..\..\..\..\GD32F4xx_Firmware_Library\CMSIS; ..\..\..\..\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include; ..\..\..\..\GD32F4xx_Firmware_Library\CMSIS\GD; ..\..\..\Utilities; ..\..\..\..\..\..\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F407xK.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../../../../../../src/: bootloader.c crc.c
    ../: gd32f4xx_it.c hal.c main.c
  group CMSIS
    ../: system_gd32f4xx.c
  group Doc
    ../: readme.txt
  group GD32F4xx_Peripherals
    ../../../../GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../../../../GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/IAR/: startup_gd32f407.s
