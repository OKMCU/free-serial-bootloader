# IAR project Project.ewp, settings and files
configuration GD32E232 (ARM, debug)
  General.OGChipSelectEditMenu: GD32E23xx8 GD GD32E23xx8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\Firmware\CMSIS; ..\..\Firmware\GD32E232_standard_peripheral\Include; ..\..\Firmware\CMSIS\GD\GD32E232\Include; ..\..; ..; ..\..\..\..\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../../src/: bootloader.c crc.c
    ../: gd32e232_it.c hal.c main.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32E232/Source/: system_gd32e232.c
  group Doc
    ../: readme.txt
  group GD32E232_Peripherals
    ../../Firmware/GD32E232_standard_peripheral/Source/: gd32e232_adc.c gd32e232_cla.c gd32e232_cmp.c gd32e232_crc.c gd32e232_dac.c gd32e232_dbg.c gd32e232_dma.c gd32e232_exti.c gd32e232_fmc.c gd32e232_fwdgt.c gd32e232_gpio.c gd32e232_i2c.c gd32e232_misc.c gd32e232_pmu.c gd32e232_rcu.c gd32e232_rtc.c gd32e232_spi.c gd32e232_syscfg.c gd32e232_timer.c gd32e232_usart.c gd32e232_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32E232/Source/IAR/: startup_gd32e232.s
