# IAR project project.ewp, settings and files
configuration free-serial-bootloader-stm32l031 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L031K6 ST STM32L031K6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L031xx
  ICCARM.CCIncludePath2: ..\; ..\CMSIS\Device\ST\STM32L0xx\Include\; ..\stm32l0xx_ll_driver\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: free-serial-bootloader-stm32l031.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l031xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../: main.c
  group BSP
    ../: hal_flash.c hal_interrupt.c hal_mcu.c hal_uart.c
    ./: startup_stm32l031xx.s system_stm32l0xx.c
